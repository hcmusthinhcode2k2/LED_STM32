# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\thinh\OneDrive\Máy tính\lib_stm32f103\C&C++\Embedded_C99\Microcontroller\stm32f10x\test_lib\stm32f103c8t6\include; C:\Users\thinh\OneDrive\Máy tính\lib_stm32f103\C&C++\Embedded_C99\Microcontroller\stm32f10x\driver\include; C:\Users\thinh\OneDrive\Máy tính\lib_stm32f103\C&C++\Embedded_C99\Microcontroller\0_Common\0_include; C:\Users\thinh\OneDrive\Máy tính\lib_stm32f103\C&C++\Embedded_C99\Microcontroller\stm32f10x\test_lib\stm32f103c8t6\include; C:\Users\thinh\OneDrive\Máy tính\lib_stm32f103\C&C++\Embedded_C99\Microcontroller\1_Application\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    source/: main.c
  group Driver
    ../../driver/: gpio.c
    ../../../1_Application/led/: led.c
